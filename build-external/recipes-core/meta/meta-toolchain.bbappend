SDK_CLASSES ?= ""
inherit ${SDK_CLASSES}
