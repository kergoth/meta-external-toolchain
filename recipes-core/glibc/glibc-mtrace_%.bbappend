inherit external_install
